# Keil uVision project project.uvprojx, settings and files
target rtthread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, LFS_CONFIG=lfs_config.h, SOFTDEVICE_PRESENT, CONFIG_GPIO_AS_PINRESET, __RTTHREAD__, USE_APP_CONFIG, RT_USING_ARM_LIBC
  c misc: --reduce_paths
  c include: applications;.;libraries\cmsis\include;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;libraries\drivers;packages\fal-v0.5.0\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\finsh;packages\FlashDB-latest\inc;.;rt-thread\include;rt-thread\components\libc\compilers\armlibc;rt-thread\components\libc\compilers\common;packages\littlefs-v2.0.5;packages\nrfx-v2.1.0;packages\nrfx-v2.1.0\drivers;packages\nrfx-v2.1.0\drivers\include;packages\nrfx-v2.1.0\mdk;packages\nrfx-v2.1.0\hal;packages\nrf5x_sdk-latest\components\libraries\util;packages\nrf5x_sdk-latest\components\libraries\experimental_section_vars;packages\nrf5x_sdk-latest\components\libraries\log;packages\nrf5x_sdk-latest\components\libraries\log\src;packages\nrf5x_sdk-latest\components\libraries\strerror;packages\nrf5x_sdk-latest\components\libraries\memobj;packages\nrf5x_sdk-latest\components\libraries\balloc;packages\nrf5x_sdk-latest\components\libraries\atomic;packages\nrf5x_sdk-latest\components\libraries\atomic_flags;packages\nrf5x_sdk-latest\components\libraries\sensorsim;packages\nrf5x_sdk-latest\components\ble\ble_link_ctx_manager;packages\nrf5x_sdk-latest\components\ble\common;packages\nrf5x_sdk-latest\components\ble\ble_advertising;packages\nrf5x_sdk-latest\components\ble\nrf_ble_gatt;packages\nrf5x_sdk-latest\components\ble\nrf_ble_qwr;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_lbs;packages\nrf5x_sdk-latest\components\softdevice\common;packages\nrf5x_sdk-latest\components\softdevice\s140\headers;packages\nrf5x_sdk-latest\components\softdevice\s140\headers\nrf52;packages\nrf5x_sdk-latest\integration\nrfx\legacy;packages\nrf5x_sdk-latest\components\ble\ble_services\ble_nus
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  group Applications
    applications/: application.c
  group cpu
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c adc.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    libraries/drivers/: drv_uart.c drv_flash.c drv_qspi_flash.c drv_gpio.c drv_adc.c drv_rtc.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c
  group FlashDB
    packages/FlashDB-latest/src/: fdb.c fdb_cmd.c fdb_file.c fdb_kvdb.c fdb_tsdb.c fdb_utils.c
    packages/FlashDB-latest/samples/: kvdb_basic_sample.c kvdb_type_blob_sample.c kvdb_type_string_sample.c tsdb_sample.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    rt-thread/components/libc/compilers/common/: time.c unistd.c
  group littlefs
    packages/littlefs-v2.0.5/: dfs_lfs.c lfs.c lfs_crc.c lfs_util.c
  group nrfx
    packages/nrfx-v2.1.0/drivers/src/: nrfx_adc.c nrfx_clock.c nrfx_comp.c nrfx_dppi.c nrfx_egu.c nrfx_gpiote.c nrfx_i2s.c nrfx_ipc.c nrfx_lpcomp.c nrfx_nfct.c nrfx_nvmc.c nrfx_pdm.c nrfx_power.c nrfx_ppi.c nrfx_pwm.c nrfx_qdec.c nrfx_qspi.c nrfx_rng.c nrfx_rtc.c nrfx_saadc.c nrfx_spi.c nrfx_spim.c nrfx_spis.c nrfx_systick.c nrfx_temp.c nrfx_timer.c nrfx_twi.c nrfx_twi_twim.c nrfx_twim.c nrfx_twis.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c nrfx_usbreg.c nrfx_wdt.c
    packages/nrfx-v2.1.0/mdk/: system_nrf52840.c arm_startup_nrf52840.s
  group SOFTDEVICE
    packages/nrf5x_sdk-latest/components/softdevice/common/: nrf_sdh.c
    packages/nrf5x_sdk-latest/integration/nrfx/legacy/: nrf_drv_clock.c
    packages/nrf5x_sdk-latest/components/libraries/util/: app_error_weak.c app_util_platform.c app_error.c
    packages/nrf5x_sdk-latest/components/libraries/experimental_section_vars/: nrf_section_iter.c
    packages/nrf5x_sdk-latest/components/libraries/strerror/: nrf_strerror.c
    packages/nrf5x_sdk-latest/components/libraries/atomic_flags/: nrf_atflags.c
    packages/nrf5x_sdk-latest/components/libraries/atomic/: nrf_atomic.c
    packages/nrf5x_sdk-latest/components/libraries/sensorsim/: sensorsim.c
    packages/nrf5x_sdk-latest/rtt_adapter/: nrf_sdh_ble_rtt.c ble_conn_params_rtt.c ble_app_uart.c
    packages/nrf5x_sdk-latest/components/ble/common/: ble_srv_common.c ble_conn_state.c ble_advdata.c
    packages/nrf5x_sdk-latest/components/ble/ble_advertising/: ble_advertising.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    packages/nrf5x_sdk-latest/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    packages/nrf5x_sdk-latest/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    packages/nrf5x_sdk-latest/components/ble/ble_services/ble_nus/: ble_nus.c
target softdevice (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: as above
  output: s140_nrf52_7.0.1_softdevice.hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, USE_APP_CONFIG, RT_USING_ARM_LIBC  APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002300 size 0x40000
  link misc: --diag_suppress 6330
